Commit message: fixed parallelism for pd parameters

File: objects/bin.urdf (robot description, URDF)
Before this commit: robot bin, 1 links, 0 joints
Links:
- link bin_body: mass None -> 0
